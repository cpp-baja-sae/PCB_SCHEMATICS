# Repository cpp-baja-sae/PCB_SCHEMATICS (continued)

## EAGLE design MasterPCB_transfer.brd (continued)

Schematic: MasterPCB_transfer.sch, sheet 11, Connectors and fusing

Parts:
C37, C42, C43, C44, C95, C97, C99, C112, C113, C114, C117, C118, C119, C122, C123, C124, C127, C128, C129, C132, C133, C134, C137, C138, C139, C142, C143, C144, C147, C148, C149, C152, C153, C154, C157, C158, C159, C162, C163, C164, C167, C168: GRM1555C1H822JE01D; 0402CAP
C39, C45, C101, C115, C120, C125, C130, C135, C140, C145, C150, C155, C160, C165: CS0402KRX7R8BB104; CAPC1005X65N
C41, C46, C107, C116, C121, C126, C131, C136, C141, C146, C151, C156, C161, C166: GRM31C5C1E474JE01L; CAPC3216X180N
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D46, D47, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D76, D77: PTVS12VS1UR,115; SOD123W
IC4, IC11, IC12, IC13, IC14, IC15, IC16, IC17, IC18, IC19, IC20, IC21, IC22, IC23: LTC4222CUH#PBF; QFN50P500X500X80-33T345N
J5, J6: TFM-140-02-L-D-WT-K; SAMTEC_TFM-140-02-L-D-WT-K
LED1, LED4, LED6, LED9, LED11, LED14, LED16, LED19, LED21, LED24, LED26, LED29, LED31, LED34, LED36, LED39, LED41, LED44, LED46, LED49, LED51, LED54, LED56, LED59, LED61, LED64, LED66, LED69: APHD1608LSURCK; LEDM168X80N
LED2, LED7, LED12, LED17, LED22, LED27, LED32, LED37, LED42, LED47, LED52, LED57, LED62, LED67: AA3021LSYSK_J3-TR; AA3021LSYSKJ3TR
LED3, LED5, LED8, LED10, LED13, LED15, LED18, LED20, LED23, LED25, LED28, LED30, LED33, LED35, LED38, LED40, LED43, LED45, LED48, LED50, LED53, LED55, LED58, LED60, LED63, LED65, LED68, LED70: APTD1608LCGCK; APT1608CGCK
LED71, LED72, LED73, LED74, LED75, LED76, LED77, LED78, LED79, LED80, LED81, LED82, LED83, LED84: SMLD12BN1WT86; LEDM168X65N
LED97, LED98, LED99, LED100, LED101, LED102, LED103, LED104, LED105, LED106, LED107, LED108, LED109, LED110, LED111, LED112, LED113, LED114: ASMT-URB4-YU802; ASMTURB4YU802
M1, M2, M3, M4, M5, M6, M7, M8, M9, M10, M11, M12, M13, M14, M15, M16, M17, M18, M19, M20, M21, M22, M23, M24, M25, M26, M27, M28: NTLUS4C12NTAG; TRANS_NTLUS3A18PZTAG
R57, R58, R65, R66, R67, R68, R69, R70, R71, R72, R117, R118, R119, R120, R121, R122, R123, R124: ERJ-PA3D1400V; ERJP03_PA3_(0603)
R89, R101, R136, R164, R174, R185, R195, R212, R223, R246, R256, R267, R277, R288, R298, R309, R319, R330, R340, R351, R361, R372, R382, R393, R403, R414, R424, R435: CRCW040212K0FKTD; RESC1005X40N
R90, R127, R137, R165, R175, R186, R196, R213, R224, R247, R257, R268, R278, R289, R299, R310, R320, R331, R341, R352, R362, R373, R383, R394, R404, R415, R425, R436: CRCW0402510RFKEDC; RESC1005X35N
R91, R128, R138, R166, R176, R187, R197, R214, R225, R248, R258, R269, R279, R290, R300, R311, R321, R332, R342, R353, R363, R374, R384, R395, R405, R416, R426, R437: CRCW04021K05FKED; RESC1005X40N
R92, R129, R139, R167, R177, R188, R198, R215, R226, R249, R259, R270, R280, R291, R301, R312, R322, R333, R343, R354, R364, R375, R385, R396, R406, R417, R427, R438: ERJ-2BWFR050X; ERJ_2LW_2BW_2B_(0402)
R93, R130, R140, R168, R178, R189, R199, R216, R228, R250, R260, R271, R281, R292, R302, R313, R323, R334, R344, R355, R365, R376, R386, R397, R407, R418, R428, R439: ESR01MZPJ100; RESC1005X40N
R94, R131, R141, R169, R179, R190, R200, R217, R240, R251, R261, R272, R282, R293, R303, R314, R324, R335, R345, R356, R366, R377, R387, R398, R408, R419, R429, R440: RC0402JR-1015KL; RESC1005X40N
R95, R132, R142, R170, R180, R191, R202, R218, R241, R252, R262, R273, R283, R294, R304, R315, R325, R336, R346, R357, R367, R378, R388, R399, R409, R420, R430, R441: CR0402-FX-1022GLF; RESC1005X40N
R96, R133, R143, R171, R181, R192, R204, R219, R242, R253, R263, R274, R284, R295, R305, R316, R326, R337, R347, R358, R368, R379, R389, R400, R410, R421, R431, R442: RC0402JR-133K3L; RESC1005X40N
R97, R99, R100, R134, R135, R144, R145, R146, R172, R173, R182, R183, R184, R193, R194, R206, R208, R210, R220, R222, R243, R244, R245, R254, R255, R264, R265, R266, R275, R276, R285, R286, R287, R296, R297, R306, R307, R308, R317, R318, R327, R328, R329, R338, R339, R348, R349, R350, R359, R360, R369, R370, R371, R380, R381, R390, R391, R392, R401, R402, R411, R412, R413, R422, R423, R432, R433, R434, R443, R444, R445, R446, R447, R448, R449, R450, R451, R452, R453, R454, R455, R456, R457, R458: ERJ-2RKF2002X; ERJ2R_(0402)
R147, R148, R149, R150: CRCW04021K30FKTD; RESC1005X40N
R517, R518, R519, R520, R521: CRG0402ZR; RESC1005X40N

Connections:
3.3V_DIGITAL: IC11.6 (ADR1), IC13.5 (ADR0), IC13.6 (ADR1), IC15.6 (ADR1), IC17.5 (ADR0), IC19.5 (ADR0), IC21.5 (ADR0), IC23.5 (ADR0), IC23.6 (ADR1), R147.2, R148.2, R149.2, R150.2; also elsewhere on the board
13.5V_BUS: IC4.11 (VDD2), IC4.30 (VDD1), IC11.11 (VDD2), IC11.30 (VDD1), IC12.11 (VDD2), IC12.30 (VDD1), IC13.11 (VDD2), IC13.30 (VDD1), IC14.11 (VDD2), IC14.30 (VDD1), IC15.11 (VDD2), IC15.30 (VDD1), IC16.11 (VDD2), IC16.30 (VDD1), IC17.11 (VDD2), IC17.30 (VDD1), IC18.11 (VDD2), IC18.30 (VDD1), IC19.11 (VDD2), IC19.30 (VDD1), IC20.11 (VDD2), IC20.30 (VDD1), IC21.11 (VDD2), IC21.30 (VDD1), IC22.11 (VDD2), IC22.30 (VDD1), IC23.11 (VDD2), IC23.30 (VDD1), R89.2, R92.1, R97.2, R99.2, R101.2, R129.1, R134.2, R136.2, R139.1, R144.2, R145.2, R164.2, R167.1, R172.2, R174.2, R177.1, R182.2, R183.2, R185.2, R188.1, R193.2, R195.2, R198.1, R206.2, R208.2, R212.2, R215.1, R220.2, R223.2, R226.1, R243.2, R244.2, R246.2, R249.1, R254.2, R256.2, R259.1, R264.2, R265.2, R267.2, R270.1, R275.2, R277.2, R280.1, R285.2, R286.2, R288.2, R291.1, R296.2, R298.2, R301.1, R306.2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; also elsewhere on the board
40G_GPIO: J5.54; also elsewhere on the board
!THERMOCOUPLE_CS: R519.2; also elsewhere on the board
ACCELEROMETER_X: D42.1 (K), J6.26; also elsewhere on the board
ACCELEROMETER_Y: D41.1 (K), J6.28; also elsewhere on the board
ACCELEROMETER_Z: D40.1 (K), J6.30; also elsewhere on the board
ADIN1_: IC4.23 (ADIN1), LED97.1 (A), R57.1
ADIN1_0: IC11.23 (ADIN1), LED99.1 (A), R65.1
ADIN1_0IN: D9.1 (K), J5.11, R65.2
ADIN1_1: IC20.23 (ADIN1), LED101.1 (A), R67.1
ADIN1_1IN: D63.1 (K), J5.21, R67.2
ADIN1_2: IC21.23 (ADIN1), LED103.1 (A), R69.1
ADIN1_2IN: D69.1 (K), J5.31, R69.2
ADIN1_3: IC12.23 (ADIN1), LED105.1 (A), R71.1
ADIN1_3IN: D15.1 (K), J6.41, R71.2
ADIN1_4: IC13.23 (ADIN1), LED107.1 (A), R117.1
ADIN1_4IN: D21.1 (K), J6.51, R117.2
ADIN1_5: IC18.23 (ADIN1), LED109.1 (A), R119.1
ADIN1_5IN: D51.1 (K), J6.61, R119.2
ADIN1_6: IC19.23 (ADIN1), LED111.1 (A), R121.1
ADIN1_6IN: D57.1 (K), J6.71, R121.2
ADIN1_7: IC14.23 (ADIN1), LED113.1 (A), R123.1
ADIN1_7IN: D27.1 (K), J6.01, R123.2
ADIN1_8_POWER_TEMP1: D33.1 (K), IC15.23 (ADIN1), J6.11; also elsewhere on the board
ADIN1_9_5V_RAIL_VO: IC16.23 (ADIN1); also elsewhere on the board
ADIN1_10_14V_RAIL_VO: IC17.23 (ADIN1); also elsewhere on the board
ADIN1_11_TEMP2_OUT: IC22.23 (ADIN1); also elsewhere on the board
ADIN1_12_TEMP4_OUT: IC23.23 (ADIN1); also elsewhere on the board
ADIN1_IN: D3.1 (K), J5.01, R57.2
ADIN2_: IC4.18 (ADIN2), LED98.1 (A), R58.1
ADIN2_0: IC11.18 (ADIN2), LED100.1 (A), R66.1
ADIN2_0IN: D12.1 (K), J5.16, R66.2
ADIN2_1: IC20.18 (ADIN2), LED102.1 (A), R68.1
ADIN2_1IN: D66.1 (K), J5.26, R68.2
ADIN2_2: IC21.18 (ADIN2), LED104.1 (A), R70.1
ADIN2_2IN: D72.1 (K), J5.36, R70.2
ADIN2_3: IC12.18 (ADIN2), LED106.1 (A), R72.1
ADIN2_3IN: D18.1 (K), J6.46, R72.2
ADIN2_4: IC13.18 (ADIN2), LED108.1 (A), R118.1
ADIN2_4IN: D24.1 (K), J6.56, R118.2
ADIN2_5: IC18.18 (ADIN2), LED110.1 (A), R120.1
ADIN2_5IN: D54.1 (K), J6.66, R120.2
ADIN2_6: IC19.18 (ADIN2), LED112.1 (A), R122.1
ADIN2_6IN: D60.1 (K), J6.76, R122.2
ADIN2_7: IC14.18 (ADIN2), LED114.1 (A), R124.1
ADIN2_7IN: D30.1 (K), J6.06, R124.2
ADIN2_8_POWER_TEMP2: D36.1 (K), IC15.18 (ADIN2), J6.16; also elsewhere on the board
ADIN2_9_POWER_TEMP3: D39.1 (K), IC16.18 (ADIN2), J6.21; also elsewhere on the board
ADIN2_10_6.5V_RAIL_VO: IC17.18 (ADIN2); also elsewhere on the board
ADIN2_11_TEMP1_OUT: IC22.18 (ADIN2); also elsewhere on the board
ADIN2_12_TEMP3_OUT: IC23.18 (ADIN2); also elsewhere on the board
ADIN2_IN: D6.1 (K), J5.06, R58.2
C1: J5.58, R517.1, R520.1
C2: J5.56, R518.1, R521.1
C3: J5.60, R519.1
DIFF1_N: D1.1 (K), J5.04; also elsewhere on the board
DIFF1_P: D2.1 (K), J5.02; also elsewhere on the board
DIFF2_N: D4.1 (K), J5.10; also elsewhere on the board
DIFF2_P: D5.1 (K), J5.08; also elsewhere on the board
DIFF3_N: D7.1 (K), J5.14; also elsewhere on the board
DIFF3_P: D8.1 (K), J5.12; also elsewhere on the board
DIFF4_N: D10.1 (K), J5.20; also elsewhere on the board
DIFF4_P: D11.1 (K), J5.18; also elsewhere on the board
DIFF5_N: D61.1 (K), J5.24; also elsewhere on the board
DIFF5_P: D62.1 (K), J5.22; also elsewhere on the board
DIFF6_N: D64.1 (K), J5.30; also elsewhere on the board
DIFF6_P: D65.1 (K), J5.28; also elsewhere on the board
DIFF7_N: D67.1 (K), J5.34; also elsewhere on the board
DIFF7_P: D68.1 (K), J5.32; also elsewhere on the board
DIFF8_N: D70.1 (K), J5.40; also elsewhere on the board
DIFF8_P: D71.1 (K), J5.38; also elsewhere on the board
DIFF9_N: D13.1 (K), J6.44; also elsewhere on the board
DIFF9_P: D14.1 (K), J6.42; also elsewhere on the board
DIFF10_N: D16.1 (K), J6.50; also elsewhere on the board
DIFF10_P: D17.1 (K), J6.48; also elsewhere on the board
DIFF11_N: D19.1 (K), J6.54; also elsewhere on the board
DIFF11_P: D20.1 (K), J6.52; also elsewhere on the board
DIFF12_N: D22.1 (K), J6.60; also elsewhere on the board
DIFF12_P: D23.1 (K), J6.58; also elsewhere on the board
DIFF13_N: D49.1 (K), J6.64; also elsewhere on the board
DIFF13_P: D50.1 (K), J6.62; also elsewhere on the board
DIFF14_N: D52.1 (K), J6.70; also elsewhere on the board
DIFF14_P: D53.1 (K), J6.68; also elsewhere on the board
DIFF15_N: D55.1 (K), J6.74; also elsewhere on the board
DIFF15_P: D56.1 (K), J6.72; also elsewhere on the board
DIFF16_N: D58.1 (K), J6.80; also elsewhere on the board
DIFF16_P: D59.1 (K), J6.78; also elsewhere on the board
DIFF_GP1_N: D25.1 (K), J6.04; also elsewhere on the board
DIFF_GP1_P: D26.1 (K), J6.02; also elsewhere on the board
DIFF_GP2_N: D28.1 (K), J6.10; also elsewhere on the board
DIFF_GP2_P: D29.1 (K), J6.08; also elsewhere on the board
DIFF_GP3_N: D31.1 (K), J6.14; also elsewhere on the board
DIFF_GP3_P: D32.1 (K), J6.12; also elsewhere on the board
DIFF_GP4_N: D34.1 (K), J6.20; also elsewhere on the board
DIFF_GP4_P: D35.1 (K), J6.18; also elsewhere on the board
DIFF_GP5_N: D37.1 (K), J6.24; also elsewhere on the board
DIFF_GP5_P: D38.1 (K), J6.22; also elsewhere on the board
DIN1: D74.1 (K), J5.66; also elsewhere on the board
DIN2: D73.1 (K), J5.68; also elsewhere on the board
DIN3: D77.1 (K), J5.70; also elsewhere on the board
DIN4: D76.1 (K), J5.72; also elsewhere on the board
DIN5: D44.1 (K), J5.74; also elsewhere on the board
DIN6: D43.1 (K), J5.76; also elsewhere on the board
DIN7: D47.1 (K), J5.78; also elsewhere on the board
DIN8: D46.1 (K), J5.80; also elsewhere on the board
FB1_: IC4.26 (FB1), R95.2, R96.2
FB1_0: IC11.26 (FB1), R142.2, R143.2
FB1_1: IC20.26 (FB1), R367.2, R368.2
FB1_2: IC21.26 (FB1), R388.2, R389.2
FB1_3: IC12.26 (FB1), R180.2, R181.2
FB1_4: IC13.26 (FB1), R202.2, R204.2
FB1_5: IC18.26 (FB1), R325.2, R326.2
FB1_6: IC19.26 (FB1), R346.2, R347.2
FB1_7: IC14.26 (FB1), R241.2, R242.2
FB1_8: IC15.26 (FB1), R262.2, R263.2
FB1_9: IC16.26 (FB1), R283.2, R284.2
FB1_10: IC17.26 (FB1), R304.2, R305.2
FB1_11: IC22.26 (FB1), R409.2, R410.2
FB1_12: IC23.26 (FB1), R430.2, R431.2
FB2_: IC4.15 (FB2), R132.2, R133.2
FB2_0: IC11.15 (FB2), R170.2, R171.2
FB2_1: IC20.15 (FB2), R378.2, R379.2
FB2_2: IC21.15 (FB2), R399.2, R400.2
FB2_3: IC12.15 (FB2), R191.2, R192.2
FB2_4: IC13.15 (FB2), R218.2, R219.2
FB2_5: IC18.15 (FB2), R336.2, R337.2
FB2_6: IC19.15 (FB2), R357.2, R358.2
FB2_7: IC14.15 (FB2), R252.2, R253.2
FB2_8: IC15.15 (FB2), R273.2, R274.2
FB2_9: IC16.15 (FB2), R294.2, R295.2
FB2_10: IC17.15 (FB2), R315.2, R316.2
FB2_11: IC22.15 (FB2), R420.2, R421.2
FB2_12: IC23.15 (FB2), R441.2, R442.2
GATE1_: IC4.28 (GATE1), R93.2, R94.2
GATE1_0: IC11.28 (GATE1), R140.2, R141.2
GATE1_1: IC20.28 (GATE1), R365.2, R366.2
GATE1_2: IC21.28 (GATE1), R386.2, R387.2
GATE1_3: IC12.28 (GATE1), R178.2, R179.2
GATE1_4: IC13.28 (GATE1), R199.2, R200.2
GATE1_5: IC18.28 (GATE1), R323.2, R324.2
GATE1_6: IC19.28 (GATE1), R344.2, R345.2
GATE1_7: IC14.28 (GATE1), R228.2, R240.2
GATE1_8: IC15.28 (GATE1), R260.2, R261.2
GATE1_9: IC16.28 (GATE1), R281.2, R282.2
GATE1_10: IC17.28 (GATE1), R302.2, R303.2
GATE1_11: IC22.28 (GATE1), R407.2, R408.2
GATE1_12: IC23.28 (GATE1), R428.2, R429.2
GATE2_: IC4.13 (GATE2), R130.2, R131.2
GATE2_0: IC11.13 (GATE2), R168.2, R169.2
GATE2_1: IC20.13 (GATE2), R376.2, R377.2
GATE2_2: IC21.13 (GATE2), R397.2, R398.2
GATE2_3: IC12.13 (GATE2), R189.2, R190.2
GATE2_4: IC13.13 (GATE2), R216.2, R217.2
GATE2_5: IC18.13 (GATE2), R334.2, R335.2
GATE2_6: IC19.13 (GATE2), R355.2, R356.2
GATE2_7: IC14.13 (GATE2), R250.2, R251.2
GATE2_8: IC15.13 (GATE2), R271.2, R272.2
GATE2_9: IC16.13 (GATE2), R292.2, R293.2
GATE2_10: IC17.13 (GATE2), R313.2, R314.2
GATE2_11: IC22.13 (GATE2), R418.2, R419.2
GATE2_12: IC23.13 (GATE2), R439.2, R440.2
GND: C37.2, C39.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C95.2, C97.2, C99.2, C101.2, C107.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, C167.2, C168.2, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A)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; also elsewhere on the board
GPIO1_: IC4.25 (GPIO1), LED1.1 (K)
GPIO1_0: IC11.25 (GPIO1), LED6.1 (K)
GPIO1_1: IC20.25 (GPIO1), LED51.1 (K)
GPIO1_2: IC21.25 (GPIO1), LED56.1 (K)
GPIO1_3: IC12.25 (GPIO1), LED11.1 (K)
GPIO1_4: IC13.25 (GPIO1), LED16.1 (K)
GPIO1_5: IC18.25 (GPIO1), LED41.1 (K)
GPIO1_6: IC19.25 (GPIO1), LED46.1 (K)
GPIO1_7: IC14.25 (GPIO1), LED21.1 (K)
GPIO1_8: IC15.25 (GPIO1), LED26.1 (K)
GPIO1_9: IC16.25 (GPIO1), LED31.1 (K)
GPIO1_10: IC17.25 (GPIO1), LED36.1 (K)
GPIO1_11: IC22.25 (GPIO1), LED61.1 (K)
GPIO1_12: IC23.25 (GPIO1), LED66.1 (K)
GPIO2_: IC4.16 (GPIO2), LED4.1 (K)
GPIO2_0: IC11.16 (GPIO2), LED9.1 (K)
GPIO2_1: IC20.16 (GPIO2), LED54.1 (K)
GPIO2_2: IC21.16 (GPIO2), LED59.1 (K)
GPIO2_3: IC12.16 (GPIO2), LED14.1 (K)
GPIO2_4: IC13.16 (GPIO2), LED19.1 (K)
GPIO2_5: IC18.16 (GPIO2), LED44.1 (K)
GPIO2_6: IC19.16 (GPIO2), LED49.1 (K)
GPIO2_7: IC14.16 (GPIO2), LED24.1 (K)
GPIO2_8: IC15.16 (GPIO2), LED29.1 (K)
GPIO2_9: IC16.16 (GPIO2), LED34.1 (K)
GPIO2_10: IC17.16 (GPIO2), LED39.1 (K)
GPIO2_11: IC22.16 (GPIO2), LED64.1 (K)
GPIO2_12: IC23.16 (GPIO2), LED69.1 (K)
IM_OUT1: J5.62; also elsewhere on the board
IM_OUT2: R518.2; also elsewhere on the board
IP_OUT1: J5.64; also elsewhere on the board
IP_OUT2: R517.2; also elsewhere on the board
MASS_ON: IC4.22 (ON), IC11.22 (ON), IC12.22 (ON), IC13.22 (ON), IC14.22 (ON), IC15.22 (ON), IC16.22 (ON), IC17.22 (ON), IC18.22 (ON), IC19.22 (ON), IC20.22 (ON), IC21.22 (ON), IC22.22 (ON), IC23.22 (ON); also elsewhere on the board
unnamed: C37.1, IC4.1 (SS)
unnamed: C39.1, IC4.2 (CONFIG), IC4.3 (INTVCC)
unnamed: C41.1, IC4.8 (TIMER)
unnamed: M1.3 (G), R93.1
unnamed: LED1.2 (A), R97.1
unnamed: LED2.2 (A), R99.1
unnamed: C42.1, R94.1
unnamed: C44.1, IC11.1 (SS)
unnamed: IC4.21 (!ALERT), LED2.1 (K)
unnamed: C45.1, IC11.2 (CONFIG), IC11.3 (INTVCC)
unnamed: LED3.1 (A), R100.1
unnamed: M2.3 (G), R130.1
unnamed: C43.1, R131.1
unnamed: LED4.2 (A), R134.1
unnamed: LED5.1 (A), R135.1
unnamed: C46.1, IC11.8 (TIMER)
unnamed: M3.3 (G), R140.1
unnamed: C95.1, R141.1
unnamed: LED6.2 (A), R144.1
unnamed: IC11.21 (!ALERT), LED7.1 (K)
unnamed: LED7.2 (A), R145.1
unnamed: LED8.1 (A), R146.1
unnamed: M4.3 (G), R168.1
unnamed: C97.1, R169.1
unnamed: LED9.2 (A), R172.1
unnamed: LED10.1 (A), R173.1
unnamed: C99.1, IC12.1 (SS)
unnamed: C101.1, IC12.2 (CONFIG), IC12.3 (INTVCC)
unnamed: C107.1, IC12.8 (TIMER)
unnamed: M5.3 (G), R178.1
unnamed: C112.1, R179.1
unnamed: LED11.2 (A), R182.1
unnamed: IC12.21 (!ALERT), LED12.1 (K)
unnamed: LED12.2 (A), R183.1
unnamed: LED13.1 (A), R184.1
unnamed: M6.3 (G), R189.1
unnamed: C113.1, R190.1
unnamed: LED14.2 (A), R193.1
unnamed: LED15.1 (A), R194.1
unnamed: C114.1, IC13.1 (SS)
unnamed: C115.1, IC13.2 (CONFIG), IC13.3 (INTVCC)
unnamed: C116.1, IC13.8 (TIMER)
unnamed: M7.3 (G), R199.1
unnamed: C117.1, R200.1
unnamed: LED16.2 (A), R206.1
unnamed: IC13.21 (!ALERT), LED17.1 (K)
unnamed: LED17.2 (A), R208.1
unnamed: LED18.1 (A), R210.1
unnamed: M8.3 (G), R216.1
unnamed: C118.1, R217.1
unnamed: LED19.2 (A), R220.1
unnamed: LED20.1 (A), R222.1
unnamed: C119.1, IC14.1 (SS)
unnamed: C120.1, IC14.2 (CONFIG), IC14.3 (INTVCC)
unnamed: C121.1, IC14.8 (TIMER)
unnamed: M9.3 (G), R228.1
unnamed: C122.1, R240.1
unnamed: LED21.2 (A), R243.1
unnamed: IC14.21 (!ALERT), LED22.1 (K)
unnamed: LED22.2 (A), R244.1
unnamed: LED23.1 (A), R245.1
unnamed: M10.3 (G), R250.1
unnamed: C123.1, R251.1
unnamed: LED24.2 (A), R254.1
unnamed: LED25.1 (A), R255.1
unnamed: C124.1, IC15.1 (SS)
unnamed: C125.1, IC15.2 (CONFIG), IC15.3 (INTVCC)
unnamed: C126.1, IC15.8 (TIMER)
unnamed: M11.3 (G), R260.1
unnamed: C127.1, R261.1
unnamed: LED26.2 (A), R264.1
unnamed: IC15.21 (!ALERT), LED27.1 (K)
unnamed: LED27.2 (A), R265.1
unnamed: LED28.1 (A), R266.1
unnamed: M12.3 (G), R271.1
unnamed: C128.1, R272.1
unnamed: LED29.2 (A), R275.1
unnamed: LED30.1 (A), R276.1
unnamed: C129.1, IC16.1 (SS)
unnamed: C130.1, IC16.2 (CONFIG), IC16.3 (INTVCC)
unnamed: C131.1, IC16.8 (TIMER)
unnamed: M13.3 (G), R281.1
unnamed: C132.1, R282.1
unnamed: LED31.2 (A), R285.1
unnamed: IC16.21 (!ALERT), LED32.1 (K)
unnamed: LED32.2 (A), R286.1
unnamed: LED33.1 (A), R287.1
unnamed: M14.3 (G), R292.1
unnamed: C133.1, R293.1
unnamed: LED34.2 (A), R296.1
unnamed: LED35.1 (A), R297.1
unnamed: C134.1, IC17.1 (SS)
unnamed: C135.1, IC17.2 (CONFIG), IC17.3 (INTVCC)
unnamed: C136.1, IC17.8 (TIMER)
unnamed: M15.3 (G), R302.1
unnamed: C137.1, R303.1
unnamed: LED36.2 (A), R306.1
unnamed: IC17.21 (!ALERT), LED37.1 (K)
unnamed: LED37.2 (A), R307.1
unnamed: LED38.1 (A), R308.1
unnamed: M16.3 (G), R313.1
unnamed: C138.1, R314.1
unnamed: LED39.2 (A), R317.1
unnamed: LED40.1 (A), R318.1
unnamed: C139.1, IC18.1 (SS)
unnamed: C140.1, IC18.2 (CONFIG), IC18.3 (INTVCC)
unnamed: C141.1, IC18.8 (TIMER)
unnamed: M17.3 (G), R323.1
unnamed: C142.1, R324.1
unnamed: LED41.2 (A), R327.1
unnamed: IC18.21 (!ALERT), LED42.1 (K)
unnamed: LED42.2 (A), R328.1
unnamed: LED43.1 (A), R329.1
unnamed: M18.3 (G), R334.1
unnamed: C143.1, R335.1
unnamed: LED44.2 (A), R338.1
unnamed: LED45.1 (A), R339.1
unnamed: C144.1, IC19.1 (SS)
unnamed: C145.1, IC19.2 (CONFIG), IC19.3 (INTVCC)
unnamed: C146.1, IC19.8 (TIMER)
unnamed: M19.3 (G), R344.1
unnamed: C147.1, R345.1
unnamed: LED46.2 (A), R348.1
unnamed: IC19.21 (!ALERT), LED47.1 (K)
unnamed: LED47.2 (A), R349.1
unnamed: LED48.1 (A), R350.1
unnamed: M20.3 (G), R355.1
unnamed: C148.1, R356.1
unnamed: LED49.2 (A), R359.1
unnamed: LED50.1 (A), R360.1
unnamed: C149.1, IC20.1 (SS)
unnamed: C150.1, IC20.2 (CONFIG), IC20.3 (INTVCC)
unnamed: C151.1, IC20.8 (TIMER)
unnamed: M21.3 (G), R365.1
unnamed: C152.1, R366.1
unnamed: LED51.2 (A), R369.1
unnamed: IC20.21 (!ALERT), LED52.1 (K)
unnamed: LED52.2 (A), R370.1
unnamed: LED53.1 (A), R371.1
unnamed: M22.3 (G), R376.1
unnamed: C153.1, R377.1
unnamed: LED54.2 (A), R380.1
unnamed: LED55.1 (A), R381.1
unnamed: C154.1, IC21.1 (SS)
unnamed: C155.1, IC21.2 (CONFIG), IC21.3 (INTVCC)
unnamed: C156.1, IC21.8 (TIMER)
unnamed: M23.3 (G), R386.1
unnamed: C157.1, R387.1
unnamed: LED56.2 (A), R390.1
unnamed: IC21.21 (!ALERT), LED57.1 (K)
unnamed: LED57.2 (A), R391.1
unnamed: LED58.1 (A), R392.1
unnamed: M24.3 (G), R397.1
unnamed: C158.1, R398.1
unnamed: LED59.2 (A), R401.1
unnamed: LED60.1 (A), R402.1
unnamed: C159.1, IC22.1 (SS)
unnamed: C160.1, IC22.2 (CONFIG), IC22.3 (INTVCC)
unnamed: C161.1, IC22.8 (TIMER)
unnamed: M25.3 (G), R407.1
unnamed: C162.1, R408.1
unnamed: LED61.2 (A), R411.1
unnamed: IC22.21 (!ALERT), LED62.1 (K)
unnamed: LED62.2 (A), R412.1
unnamed: LED63.1 (A), R413.1
unnamed: M26.3 (G), R418.1
unnamed: C163.1, R419.1
unnamed: LED64.2 (A), R422.1
unnamed: LED65.1 (A), R423.1
unnamed: C164.1, IC23.1 (SS)
unnamed: C165.1, IC23.2 (CONFIG), IC23.3 (INTVCC)
unnamed: C166.1, IC23.8 (TIMER)
unnamed: M27.3 (G), R428.1
unnamed: C167.1, R429.1
unnamed: LED66.2 (A), R432.1
unnamed: IC23.21 (!ALERT), LED67.1 (K)
unnamed: LED67.2 (A), R433.1
unnamed: LED68.1 (A), R434.1
unnamed: M28.3 (G), R439.1
unnamed: C168.1, R440.1
unnamed: LED69.2 (A), R443.1
unnamed: LED70.1 (A), R444.1
unnamed: LED71.2 (A), R445.2
unnamed: LED72.2 (A), R446.2
unnamed: LED73.2 (A), R447.2
unnamed: LED74.2 (A), R448.2
unnamed: LED75.2 (A), R449.2
unnamed: LED76.2 (A), R450.2
unnamed: LED77.2 (A), R451.2
unnamed: LED78.2 (A), R452.2
unnamed: LED79.2 (A), R453.2
unnamed: LED80.2 (A), R454.2
unnamed: LED81.2 (A), R455.2
unnamed: LED82.2 (A), R456.2
unnamed: LED83.2 (A), R457.2
unnamed: LED84.2 (A), R458.2
OV1_: IC4.32 (OV1), R90.2, R91.1
OV1_0: IC11.32 (OV1), R137.2, R138.1
OV1_1: IC20.32 (OV1), R362.2, R363.1
OV1_2: IC21.32 (OV1), R383.2, R384.1
OV1_3: IC12.32 (OV1), R175.2, R176.1
OV1_4: IC13.32 (OV1), R196.2, R197.1
OV1_5: IC18.32 (OV1), R320.2, R321.1
OV1_6: IC19.32 (OV1), R341.2, R342.1
OV1_7: IC14.32 (OV1), R224.2, R225.1
OV1_8: IC15.32 (OV1), R257.2, R258.1
OV1_9: IC16.32 (OV1), R278.2, R279.1
OV1_10: IC17.32 (OV1), R299.2, R300.1
OV1_11: IC22.32 (OV1), R404.2, R405.1
OV1_12: IC23.32 (OV1), R425.2, R426.1
OV2_: IC4.9 (OV2), R127.2, R128.1
OV2_0: IC11.9 (OV2), R165.2, R166.1
OV2_1: IC20.9 (OV2), R373.2, R374.1
OV2_2: IC21.9 (OV2), R394.2, R395.1
OV2_3: IC12.9 (OV2), R186.2, R187.1
OV2_4: IC13.9 (OV2), R213.2, R214.1
OV2_5: IC18.9 (OV2), R331.2, R332.1
OV2_6: IC19.9 (OV2), R352.2, R353.1
OV2_7: IC14.9 (OV2), R247.2, R248.1
OV2_8: IC15.9 (OV2), R268.2, R269.1
OV2_9: IC16.9 (OV2), R289.2, R290.1
OV2_10: IC17.9 (OV2), R310.2, R311.1
OV2_11: IC22.9 (OV2), R415.2, R416.1
OV2_12: IC23.9 (OV2), R436.2, R437.1
SCL1: IC4.20 (SCL), IC11.20 (SCL), IC12.20 (SCL), IC13.20 (SCL), IC18.20 (SCL), IC20.20 (SCL), IC21.20 (SCL), R148.1; also elsewhere on the board
SCL2: IC14.20 (SCL), IC15.20 (SCL), IC16.20 (SCL), IC17.20 (SCL), IC19.20 (SCL), IC22.20 (SCL), IC23.20 (SCL), R150.1; also elsewhere on the board
SDA1: IC4.19 (SDA), IC11.19 (SDA), IC12.19 (SDA), IC13.19 (SDA), IC18.19 (SDA), IC20.19 (SDA), IC21.19 (SDA), R147.1; also elsewhere on the board
SDA2: IC14.19 (SDA), IC15.19 (SDA), IC16.19 (SDA), IC17.19 (SDA), IC19.19 (SDA), IC22.19 (SDA), IC23.19 (SDA), R149.1; also elsewhere on the board
SENSE1_: IC4.29 (SENSE1-), M1.1 (D), M1.2 (D), M1.5 (D), M1.6 (D), M1.7 (D), R92.2
SENSE1_0: IC11.29 (SENSE1-), M3.1 (D), M3.2 (D), M3.5 (D), M3.6 (D), M3.7 (D), R139.2
SENSE1_1: IC20.29 (SENSE1-), M21.1 (D), M21.2 (D), M21.5 (D), M21.6 (D), M21.7 (D), R364.2
SENSE1_2: IC21.29 (SENSE1-), M23.1 (D), M23.2 (D), M23.5 (D), M23.6 (D), M23.7 (D), R385.2
SENSE1_3: IC12.29 (SENSE1-), M5.1 (D), M5.2 (D), M5.5 (D), M5.6 (D), M5.7 (D), R177.2
SENSE1_4: IC13.29 (SENSE1-), M7.1 (D), M7.2 (D), M7.5 (D), M7.6 (D), M7.7 (D), R198.2
SENSE1_5: IC18.29 (SENSE1-), M17.1 (D), M17.2 (D), M17.5 (D), M17.6 (D), M17.7 (D), R322.2
SENSE1_6: IC19.29 (SENSE1-), M19.1 (D), M19.2 (D), M19.5 (D), M19.6 (D), M19.7 (D), R343.2
SENSE1_7: IC14.29 (SENSE1-), M9.1 (D), M9.2 (D), M9.5 (D), M9.6 (D), M9.7 (D), R226.2
SENSE1_8: IC15.29 (SENSE1-), M11.1 (D), M11.2 (D), M11.5 (D), M11.6 (D), M11.7 (D), R259.2
SENSE1_9: IC16.29 (SENSE1-), M13.1 (D), M13.2 (D), M13.5 (D), M13.6 (D), M13.7 (D), R280.2
SENSE1_10: IC17.29 (SENSE1-), M15.1 (D), M15.2 (D), M15.5 (D), M15.6 (D), M15.7 (D), R301.2
SENSE1_11: IC22.29 (SENSE1-), M25.1 (D), M25.2 (D), M25.5 (D), M25.6 (D), M25.7 (D), R406.2
SENSE1_12: IC23.29 (SENSE1-), M27.1 (D), M27.2 (D), M27.5 (D), M27.6 (D), M27.7 (D), R427.2
SENSE2_: IC4.12 (SENSE2-), M2.1 (D), M2.2 (D), M2.5 (D), M2.6 (D), M2.7 (D), R129.2
SENSE2_0: IC11.12 (SENSE2-), M4.1 (D), M4.2 (D), M4.5 (D), M4.6 (D), M4.7 (D), R167.2
SENSE2_1: IC20.12 (SENSE2-), M22.1 (D), M22.2 (D), M22.5 (D), M22.6 (D), M22.7 (D), R375.2
SENSE2_2: IC21.12 (SENSE2-), M24.1 (D), M24.2 (D), M24.5 (D), M24.6 (D), M24.7 (D), R396.2
SENSE2_3: IC12.12 (SENSE2-), M6.1 (D), M6.2 (D), M6.5 (D), M6.6 (D), M6.7 (D), R188.2
SENSE2_4: IC13.12 (SENSE2-), M8.1 (D), M8.2 (D), M8.5 (D), M8.6 (D), M8.7 (D), R215.2
SENSE2_5: IC18.12 (SENSE2-), M18.1 (D), M18.2 (D), M18.5 (D), M18.6 (D), M18.7 (D), R333.2
SENSE2_6: IC19.12 (SENSE2-), M20.1 (D), M20.2 (D), M20.5 (D), M20.6 (D), M20.7 (D), R354.2
SENSE2_7: IC14.12 (SENSE2-), M10.1 (D), M10.2 (D), M10.5 (D), M10.6 (D), M10.7 (D), R249.2
SENSE2_8: IC15.12 (SENSE2-), M12.1 (D), M12.2 (D), M12.5 (D), M12.6 (D), M12.7 (D), R270.2
SENSE2_9: IC16.12 (SENSE2-), M14.1 (D), M14.2 (D), M14.5 (D), M14.6 (D), M14.7 (D), R291.2
SENSE2_10: IC17.12 (SENSE2-), M16.1 (D), M16.2 (D), M16.5 (D), M16.6 (D), M16.7 (D), R312.2
SENSE2_11: IC22.12 (SENSE2-), M26.1 (D), M26.2 (D), M26.5 (D), M26.6 (D), M26.7 (D), R417.2
SENSE2_12: IC23.12 (SENSE2-), M28.1 (D), M28.2 (D), M28.5 (D), M28.6 (D), M28.7 (D), R438.2
SOURCE1_: IC4.27 (SOURCE1), J5.03, M1.4 (S), M1.8 (S), R95.1, R100.2
SOURCE1_0: IC11.27 (SOURCE1), J5.13, M3.4 (S), M3.8 (S), R142.1, R146.2
SOURCE1_1: IC20.27 (SOURCE1), J5.23, M21.4 (S), M21.8 (S), R367.1, R371.2
SOURCE1_2: IC21.27 (SOURCE1), J5.33, M23.4 (S), M23.8 (S), R388.1, R392.2
SOURCE1_3: IC12.27 (SOURCE1), J6.43, M5.4 (S), M5.8 (S), R180.1, R184.2
SOURCE1_4: IC13.27 (SOURCE1), J6.53, M7.4 (S), M7.8 (S), R202.1, R210.2
SOURCE1_5: IC18.27 (SOURCE1), J6.63, M17.4 (S), M17.8 (S), R325.1, R329.2
SOURCE1_6: IC19.27 (SOURCE1), J6.73, M19.4 (S), M19.8 (S), R346.1, R350.2
SOURCE1_7: IC14.27 (SOURCE1), J6.03, M9.4 (S), M9.8 (S), R241.1, R245.2
SOURCE1_8: IC15.27 (SOURCE1), J6.13, M11.4 (S), M11.8 (S), R262.1, R266.2
SOURCE1_9: IC16.27 (SOURCE1), J6.23, M13.4 (S), M13.8 (S), R283.1, R287.2
SOURCE1_10: IC17.27 (SOURCE1), J5.57, M15.4 (S), M15.8 (S), R304.1, R308.2
SOURCE1_11: IC22.27 (SOURCE1), J5.65, M25.4 (S), M25.8 (S), R409.1, R413.2
SOURCE1_12: IC23.27 (SOURCE1), J5.73, M27.4 (S), M27.8 (S), R430.1, R434.2
SOURCE2_: IC4.14 (SOURCE2), J5.05, M2.4 (S), M2.8 (S), R132.1, R135.2
SOURCE2_0: IC11.14 (SOURCE2), J5.15, M4.4 (S), M4.8 (S), R170.1, R173.2
SOURCE2_1: IC20.14 (SOURCE2), J5.25, M22.4 (S), M22.8 (S), R378.1, R381.2
SOURCE2_2: IC21.14 (SOURCE2), J5.35, M24.4 (S), M24.8 (S), R399.1, R402.2
SOURCE2_3: IC12.14 (SOURCE2), J6.45, M6.4 (S), M6.8 (S), R191.1, R194.2
SOURCE2_4: IC13.14 (SOURCE2), J6.55, M8.4 (S), M8.8 (S), R218.1, R222.2
SOURCE2_5: IC18.14 (SOURCE2), J6.65, M18.4 (S), M18.8 (S), R336.1, R339.2
SOURCE2_6: IC19.14 (SOURCE2), J6.75, M20.4 (S), M20.8 (S), R357.1, R360.2
SOURCE2_7: IC14.14 (SOURCE2), J6.05, M10.4 (S), M10.8 (S), R252.1, R255.2
SOURCE2_8: IC15.14 (SOURCE2), J6.15, M12.4 (S), M12.8 (S), R273.1, R276.2
SOURCE2_9: IC16.14 (SOURCE2), J6.25, M14.4 (S), M14.8 (S), R294.1, R297.2
SOURCE2_10: IC17.14 (SOURCE2), J5.59, M16.4 (S), M16.8 (S), R315.1, R318.2
SOURCE2_11: IC22.14 (SOURCE2), J5.67, M26.4 (S), M26.8 (S), R420.1, R423.2
SOURCE2_12: IC23.14 (SOURCE2), J5.75, M28.4 (S), M28.8 (S), R441.1, R444.2
THERMOCOUPLE_MISO: R521.2; also elsewhere on the board
THERMOCOUPLE_SCLK: R520.2; also elsewhere on the board
UV1_: IC4.31 (UV1), R89.1, R90.1
UV1_0: IC11.31 (UV1), R136.1, R137.1
UV1_1: IC20.31 (UV1), R361.1, R362.1
UV1_2: IC21.31 (UV1), R382.1, R383.1
UV1_3: IC12.31 (UV1), R174.1, R175.1
UV1_4: IC13.31 (UV1), R195.1, R196.1
UV1_5: IC18.31 (UV1), R319.1, R320.1
UV1_6: IC19.31 (UV1), R340.1, R341.1
UV1_7: IC14.31 (UV1), R223.1, R224.1
UV1_8: IC15.31 (UV1), R256.1, R257.1
UV1_9: IC16.31 (UV1), R277.1, R278.1
UV1_10: IC17.31 (UV1), R298.1, R299.1
UV1_11: IC22.31 (UV1), R403.1, R404.1
UV1_12: IC23.31 (UV1), R424.1, R425.1
UV2_: IC4.10 (UV2), R101.1, R127.1
UV2_0: IC11.10 (UV2), R164.1, R165.1
UV2_1: IC20.10 (UV2), R372.1, R373.1
UV2_2: IC21.10 (UV2), R393.1, R394.1
UV2_3: IC12.10 (UV2), R185.1, R186.1
UV2_4: IC13.10 (UV2), R212.1, R213.1
UV2_5: IC18.10 (UV2), R330.1, R331.1
UV2_6: IC19.10 (UV2), R351.1, R352.1
UV2_7: IC14.10 (UV2), R246.1, R247.1
UV2_8: IC15.10 (UV2), R267.1, R268.1
UV2_9: IC16.10 (UV2), R288.1, R289.1
UV2_10: IC17.10 (UV2), R309.1, R310.1
UV2_11: IC22.10 (UV2), R414.1, R415.1
UV2_12: IC23.10 (UV2), R435.1, R436.1

Notes on the sheet:
Output indicator
Power bad indicator
Fault or ADC conversion indicator
On pin - Hold low on start up Mass clear fault register
Feedback network
MOSFET with harmonic suppression and inrush current resistor
Current shunt
UV OV feedback network
ESD diodes
Strain Gauge differential connectors
General differential sensor inputs
Analog accelerometer
SPI LINK 40G accelerometer
SPI LINK thermocouple
Single ended digital inputs Splice GND node between 2 sensors 2 sensors share same short circuit protection
Visual indicator that power is available to the node at this segment of the board
Output power supply temperature voltage
Device address from data sheet
ADIN input voltage clamp and indicator
